# IAR project stm32wb_zigbee_mw.ewp, settings and files
configuration standard (ARM)
  General.OGChipSelectEditMenu: STM32WB55RG ST STM32WB55RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WB55xx; USE_STM32WBXX_NUCLEO; ZIGBEE_WB
  ICCARM.IExtraOptions: --diag_suppress Pe111; --diag_suppress Pe188
  ICCARM.CCIncludePath2: ../../../../zigbee/stack/include/mac; ../../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../../../../../../../Drivers/CMSIS/Core/Include; ../../../../zigbee/stack/include; ../../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc; ../../../../zigbee/stack/include/M4; ../../../../zigbee/core/inc; ../../../../zigbee/stack
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: standard_M0.bin
  postbuild: CMD /C "copy standard\Exe\stm32wb_zigbee_wb_lib.a ..\..\"
  ILINK.IlinkOutputFile: standard.out
  ILINK.IlinkIcfFile: stm32wb55xx_standard.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Middlewares/STM32_WPAN/zigbee/stack
    ../../../stack/: pletoh.c
  group Middlewares/STM32_WPAN/zigbee/stack/zcl
    ../../../stack/zcl/: zcl_attr.c zcl_attr_float.c zcl_attr_integer.c zcl_attr_list.c zcl_attr_report.c zcl_attr_string.c zcl_cluster.c zcl_cluster_init.c zcl_cluster_scene.c zcl_command_ind.c zcl_header.c
  group Middlewares/STM32_WPAN/zigbee/stack/zcl/commission
    ../../../stack/zcl/commission/: zcl_commission_client.c zcl_commission_server.c
  group Middlewares/STM32_WPAN/zigbee/stack/zcl/general
    ../../../stack/zcl/general/: zcl_alarm_client.c zcl_alarm_server.c zcl_ballast_config_client.c zcl_ballast_config_server.c zcl_basic_client.c zcl_color_client.c zcl_color_server.c zcl_dehum_ctrl_client.c zcl_dehum_ctrl_server.c zcl_device_temp_client.c zcl_device_temp_server.c zcl_diagnostics_client.c zcl_doorlock_client.c zcl_doorlock_server.c zcl_elec_meas_client.c zcl_elec_meas_server.c zcl_fan_client.c zcl_fan_server.c zcl_groups_client.c zcl_groups_server.c zcl_identify_client.c zcl_identify_server.c zcl_illum_level_client.c zcl_illum_level_server.c zcl_illum_meas_client.c zcl_illum_meas_server.c zcl_level_client.c zcl_level_server.c zcl_meter_id_client.c zcl_meter_id_server.c zcl_nearest_gw_client.c zcl_nearest_gw_server.c zcl_occupancy_client.c zcl_occupancy_server.c zcl_onoff_client.c zcl_onoff_server.c zcl_onoff_swconfig_client.c zcl_onoff_swconfig_server.c zcl_ota_client.c zcl_ota_server.c zcl_poll_control_client.c zcl_poll_control_server.c zcl_power_config_client.c zcl_power_config_server.c zcl_power_profile_client.c zcl_power_profile_server.c zcl_press_meas_client.c zcl_press_meas_server.c zcl_pump_client.c zcl_pump_server.c zcl_rssi_loc_client.c zcl_rssi_loc_server.c zcl_scenes_client.c zcl_scenes_server.c zcl_temp_meas_client.c zcl_temp_meas_server.c zcl_therm_client.c zcl_therm_server.c zcl_therm_ui_client.c zcl_therm_ui_server.c zcl_time_client.c zcl_time_server.c zcl_voice_client.c zcl_voice_server.c zcl_water_content_client.c zcl_water_content_server.c zcl_window_client.c zcl_window_server.c
  group Middlewares/STM32_WPAN/zigbee/stack/zcl/se
    ../../../stack/zcl/se/: local_zcl_tunnel.h zcl_drlc_client.c zcl_drlc_server.c zcl_messaging_client.c zcl_messaging_server.c zcl_price_client.c zcl_price_server.c zcl_simplemeter_client.c zcl_simplemeter_server.c zcl_tunnel_client.c zcl_tunnel_server.c
  group Middlewares/STM32_WPAN/zigbee/stack/zcl/security
    ../../../stack/zcl/security/: zcl_ias_ace_client.c zcl_ias_ace_server.c zcl_ias_wd_client.c zcl_ias_wd_server.c zcl_ias_zone_client.c zcl_ias_zone_server.c
  group Middlewares/STM32_WPAN/zigbee/stack/zcl/st_custom
    ../../../stack/zcl/st_custom/: zcl_custom_ls_client.c zcl_custom_ls_server.c zcl_custom_matrix_client.c zcl_custom_matrix_server.c
  group Middlewares/STM32_WPAN/zigbee/utilities
    ../../../utilities/: zigbee.string.c
